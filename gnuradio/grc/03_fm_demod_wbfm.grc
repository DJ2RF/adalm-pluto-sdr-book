options:
  parameters:
    generate_options: qt_gui
    id: wbfm_receiver
    output_language: python
    title: WBFM Receiver (Pluto)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: f_station
  id: variable
  parameters:
    value: '100300000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    uri: ip:pluto.local
    samplerate: samp_rate
    bandwidth: samp_rate
    frequency: f_station
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    bbdc: 'True'
    buffer_size: '32768'
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    cutoff_freq: '100000'
    transition_width: '30000'
    window: window.WIN_HAMMING
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    quad_rate: quad_rate
    audio_decimation: '5'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    interp: '6'
    decim: '5'
    taps: ''
    fractional_bw: '0.4'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    fftsize: '1024'
    fc: f_station
    bw: samp_rate
    label: RX Spectrum
    label1: ''''''
  states: {}

connections:
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
