options:
  parameters:
    author: DJ2RF
    category: '[Pluto TX Tests]'
    comment: CW carrier test – USE DUMMY LOAD ONLY
    description: Simple CW carrier test using Pluto TX
    generate_options: qt_gui
    id: tx_cw_test
    output_language: python
    title: CW TX Test (Pluto) – DUMMY LOAD ONLY
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: f_tx
  id: variable
  parameters:
    value: '435000000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    waveform: analog.GR_COS_WAVE
    frequency: '1000'
    amplitude: '0.2'
    offset: '0'
    samp_rate: samp_rate
    phase: '0'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    uri: ip:pluto.local
    samplerate: samp_rate
    bandwidth: samp_rate
    frequency: f_tx
    attenuation: tx_gain
    cyclic: 'False'
    buffer_size: '32768'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
