options:
  parameters:
    author: DJ2RF
    category: '[Digital Demos]'
    comment: 'FSK demo (no hardware): generate 2-FSK + simple demod'
    description: 2-FSK generator + quadrature demod + clock recovery
    generate_options: qt_gui
    id: fsk_demo
    output_language: python
    title: 2-FSK Demo (Baseband)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: baud
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/baud)
  states: {}
- name: f_dev
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: sens
  id: variable
  parameters:
    value: 2*math.pi*f_dev/samp_rate
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    type: byte
    min: '0'
    max: '2'
    seed: '0'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    dtype: float
    symbol_table: '[-1.0, 1.0]'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    type: float
    interp: sps
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: '1.0'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: sens
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    type: complex
    samples_per_second: samp_rate
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    cutoff_freq: '6000'
    transition_width: '2000'
    window: window.WIN_HAMMING
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    dtype: float
    omega: sps
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    gain_mu: '0.175'
    omega_relative_limit: '0.005'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    fftsize: '2048'
    fc: '0'
    bw: samp_rate
    label: FSK Spectrum (Baseband)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    type: float
    samp_rate: samp_rate
    size: '2000'
    ymin: '-2'
    ymax: '2'
    grid: 'True'
    label1: Discriminator
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    type: byte
    samp_rate: baud
    size: '400'
    ymin: '-0.5'
    ymax: '1.5'
    grid: 'True'
    label1: Recovered Bits (0/1)
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
