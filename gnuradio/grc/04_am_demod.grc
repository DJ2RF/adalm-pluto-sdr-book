options:
  parameters:
    generate_options: qt_gui
    id: am_receiver
    output_language: python
    title: AM Receiver (Pluto)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: f_station
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    uri: ip:pluto.local
    samplerate: samp_rate
    bandwidth: '200000'
    frequency: f_station
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    bbdc: 'True'
    buffer_size: '32768'
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    cutoff_freq: '45000'
    transition_width: '15000'
    window: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    samp_rate: quad_rate
    cutoff_freq: '50'
    transition_width: '100'
    window: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    samp_rate: quad_rate
    cutoff_freq: '5000'
    transition_width: '2000'
    window: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    interp: '6'
    decim: '25'
    taps: ''
    fractional_bw: '0.4'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    fftsize: '1024'
    fc: f_station
    bw: samp_rate
    label: RX Spectrum
    label1: ''''''
  states: {}

connections:
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_complex_to_mag_0, '0', high_pass_filter_0, '0']
- [high_pass_filter_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
