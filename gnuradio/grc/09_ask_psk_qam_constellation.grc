options:
  parameters:
    author: DJ2RF
    category: '[Digital Demos]'
    comment: ASK / PSK / QAM constellation demo (no hardware)
    description: Generate 4-ASK, BPSK, QPSK, 16QAM and show constellation
    generate_options: qt_gui
    id: ask_psk_qam_constellation
    output_language: python
    title: ASK / PSK / QAM Constellations (Baseband)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/sym_rate)
  states: {}
- name: mode
  id: variable
  parameters:
    value: '2'
  states: {}
- name: analog_random_source_x_ask
  id: analog_random_source_x
  parameters:
    type: byte
    min: '0'
    max: '4'
    seed: '0'
  states: {}
- name: digital_chunks_to_symbols_xx_ask
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    dtype: float
    symbol_table: '[0.25, 0.5, 0.75, 1.0]'
  states: {}
- name: blocks_repeat_ask
  id: blocks_repeat
  parameters:
    type: float
    interp: sps
  states: {}
- name: blocks_float_to_complex_ask
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: analog_random_source_x_bpsk
  id: analog_random_source_x
  parameters:
    type: byte
    min: '0'
    max: '2'
    seed: '1'
  states: {}
- name: digital_chunks_to_symbols_xx_bpsk
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    dtype: complex
    symbol_table: '[-1+0j, 1+0j]'
  states: {}
- name: blocks_repeat_bpsk
  id: blocks_repeat
  parameters:
    type: complex
    interp: sps
  states: {}
- name: analog_random_source_x_qpsk
  id: analog_random_source_x
  parameters:
    type: byte
    min: '0'
    max: '4'
    seed: '2'
  states: {}
- name: digital_chunks_to_symbols_xx_qpsk
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    dtype: complex
    symbol_table: '[0.707+0.707j, 0.707-0.707j, -0.707+0.707j, -0.707-0.707j]'
  states: {}
- name: blocks_repeat_qpsk
  id: blocks_repeat
  parameters:
    type: complex
    interp: sps
  states: {}
- name: analog_random_source_x_16qam
  id: analog_random_source_x
  parameters:
    type: byte
    min: '0'
    max: '16'
    seed: '3'
  states: {}
- name: digital_chunks_to_symbols_xx_16qam
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    dtype: complex
    symbol_table: '[ (-3-3j)/3.1623, (-3-1j)/3.1623, (-3+1j)/3.1623, (-3+3j)/3.1623, (-1-3j)/3.1623, (-1-1j)/3.1623, (-1+1j)/3.1623, (-1+3j)/3.1623, ( 1-3j)/3.1623, ( 1-1j)/3.1623, ( 1+1j)/3.1623, ( 1+3j)/3.1623, ( 3-3j)/3.1623, ( 3-1j)/3.1623, ( 3+1j)/3.1623, ( 3+3j)/3.1623 ]'
  states: {}
- name: blocks_repeat_16qam
  id: blocks_repeat
  parameters:
    type: complex
    interp: sps
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    type: complex
    num_inputs: '4'
    num_outputs: '1'
    input_index: mode
    output_index: '0'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    type: complex
    samples_per_second: samp_rate
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    type: complex
    size: '2048'
    samp_rate: samp_rate
    autoscale: 'True'
    grid: 'True'
    label1: Selected Constellation
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    fftsize: '2048'
    fc: '0'
    bw: samp_rate
    label: Spectrum (Selected)
  states: {}

connections:
- [analog_random_source_x_ask, '0', digital_chunks_to_symbols_xx_ask, '0']
- [digital_chunks_to_symbols_xx_ask, '0', blocks_repeat_ask, '0']
- [blocks_repeat_ask, '0', blocks_float_to_complex_ask, '0']
- [analog_random_source_x_bpsk, '0', digital_chunks_to_symbols_xx_bpsk, '0']
- [digital_chunks_to_symbols_xx_bpsk, '0', blocks_repeat_bpsk, '0']
- [analog_random_source_x_qpsk, '0', digital_chunks_to_symbols_xx_qpsk, '0']
- [digital_chunks_to_symbols_xx_qpsk, '0', blocks_repeat_qpsk, '0']
- [analog_random_source_x_16qam, '0', digital_chunks_to_symbols_xx_16qam, '0']
- [digital_chunks_to_symbols_xx_16qam, '0', blocks_repeat_16qam, '0']
- [blocks_float_to_complex_ask, '0', blocks_selector_0, '0']
- [blocks_repeat_bpsk, '0', blocks_selector_0, '1']
- [blocks_repeat_qpsk, '0', blocks_selector_0, '2']
- [blocks_repeat_16qam, '0', blocks_selector_0, '3']
- [blocks_selector_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
