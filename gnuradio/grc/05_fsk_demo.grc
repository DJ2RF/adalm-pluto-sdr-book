options:
  parameters:
    generate_options: qt_gui
    id: nbfm_receiver
    output_language: python
    title: NBFM Receiver (Pluto)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: f_rx
  id: variable
  parameters:
    value: '145500000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: max_dev
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: tau
  id: variable
  parameters:
    value: '300e-6'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    uri: ip:pluto.local
    samplerate: samp_rate
    bandwidth: samp_rate
    frequency: f_rx
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    bbdc: 'True'
    buffer_size: '32768'
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    cutoff_freq: '15000'
    transition_width: '5000'
    window: window.WIN_HAMMING
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (quad_rate)/(2*math.pi*max_dev)
  states: {}
- name: analog_deemph_0
  id: analog_deemph
  parameters:
    samp_rate: quad_rate
    tau: tau
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    samp_rate: quad_rate
    cutoff_freq: '3500'
    transition_width: '1500'
    window: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    interp: '6'
    decim: '25'
    taps: ''
    fractional_bw: '0.4'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    fftsize: '1024'
    fc: f_rx
    bw: samp_rate
    label: RX Spectrum
  states: {}

connections:
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_deemph_0, '0']
- [analog_deemph_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
