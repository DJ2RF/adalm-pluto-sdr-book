options:
  parameters:
    author: DJ2RF
    category: '[Pluto TX/RX Digital]'
    comment: QPSK TX->RX loopback. USE ATTENUATOR ONLY.
    description: Generate QPSK baseband, transmit via Pluto, receive via Pluto, show constellation.
    generate_options: qt_gui
    id: qpsk_tx_rx_loopback
    output_language: python
    title: QPSK TX/RX Loopback (Pluto) – ATTENUATOR ONLY
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/sym_rate)
  states: {}
- name: f0
  id: variable
  parameters:
    value: '435000000'
  states: {}
- name: tx_atten
  id: variable
  parameters:
    value: '40'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: sym_offset
  id: variable
  parameters:
    value: int(sps/2)
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    type: byte
    min: '0'
    max: '4'
    seed: '0'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    dtype: complex
    symbol_table: '[0.707+0.707j, 0.707-0.707j, -0.707+0.707j, -0.707-0.707j]'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    type: complex
    interp: sps
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: '0.15'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    uri: ip:pluto.local
    samplerate: samp_rate
    bandwidth: samp_rate
    frequency: f0
    attenuation: tx_atten
    cyclic: 'False'
    buffer_size: '32768'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    uri: ip:pluto.local
    samplerate: samp_rate
    bandwidth: samp_rate
    frequency: f0
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    bbdc: 'True'
    buffer_size: '32768'
    type: fc32
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    type: complex
    n: sps
    offset: sym_offset
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    w: '0.02'
    order: '4'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    type: complex
    size: '4096'
    samp_rate: sym_rate
    autoscale: 'True'
    grid: 'True'
    label1: QPSK Constellation (RX)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    fftsize: '2048'
    fc: f0
    bw: samp_rate
    label: RX Spectrum (Loopback)
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_keep_one_in_n_0, '0', digital_costas_loop_cc_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
