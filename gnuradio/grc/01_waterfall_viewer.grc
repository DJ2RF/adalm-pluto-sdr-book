options:
  parameters:
    generate_options: qt_gui
    id: waterfall_viewer
    output_language: python
    title: Waterfall Viewer (Pluto)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: f0
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    uri: ip:pluto.local
    samplerate: samp_rate
    bandwidth: samp_rate
    frequency: f0
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    bbdc: 'True'
    buffer_size: '32768'
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    type: complex
    fftsize: '1024'
    fc: f0
    bw: samp_rate
    intensity_range: '-140,10'
    color_map: '0'
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
