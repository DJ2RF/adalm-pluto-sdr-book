options:
  parameters:
    generate_options: qt_gui
    id: iq_recorder
    output_language: python
    title: IQ Recorder (Pluto)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: f0
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: out_file
  id: variable
  parameters:
    value: '''../data/iq_recordings/pluto_iq_2Msps_100MHz.cfile'''
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    uri: ip:pluto.local
    samplerate: samp_rate
    bandwidth: samp_rate
    frequency: f0
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    bbdc: 'True'
    buffer_size: '32768'
    type: fc32
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: complex
    file: out_file
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    fftsize: '1024'
    fc: f0
    bw: samp_rate
    label: IQ Recording (Live Spectrum)
    label1: ''''''
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
